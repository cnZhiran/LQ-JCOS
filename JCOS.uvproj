# Keil uVision project JCOS.uvproj, settings and files
target JCOS (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: JCOS +hex
  c flags: Optimize=8 SizeSpeed=1
  group USER
    ./: main.c
  group DRIVER
    ./DRIVER/: ds1302.c iic.c onewire.c
